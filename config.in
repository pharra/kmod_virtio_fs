## config.in
```kconfig
config KERNEL_VIRTIO_FS
    bool "Enable Virtiofs support"
    default y
    depends on KERNEL_FUSE_FS
    help
      Enable support for Virtiofs in the kernel.
```
